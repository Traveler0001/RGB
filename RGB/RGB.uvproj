# Keil uVision project RGB.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: RGB +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group USER
    ./USER/: main.c
  group HEADER
    $TC_ROOT$/../../keil储存/MDK5_C51/HEADER/: STC12C5A60S2.h
